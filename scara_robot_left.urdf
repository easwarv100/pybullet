Commit message: Add files via upload

File: scara_robot_left.urdf (robot description, URDF)
Before this commit: robot scara_robot_left, 9 links, 8 joints
Joints:
- joint rotation2: limit lower=-3.00 upper=3.00 effort=1000 velocity=1000 -> lower=-10.00 upper=10.00 effort=1000 velocity=1000
